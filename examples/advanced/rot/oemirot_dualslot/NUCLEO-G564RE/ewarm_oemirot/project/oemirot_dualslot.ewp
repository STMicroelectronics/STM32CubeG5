# IAR project oemirot_dualslot.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 0
  ICCARM.CCDefines: STM32G564xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict; --preinclude ../../oemirot/boot_pre_include_global.h
  ICCARM.PreInclude: ../../oemirot/user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/mbedtls/configs; ../../../../../../../middleware/mbedtls/include; ../../../../../../../middleware/mbedtls/include/mbedtls; ../../../../../../../middleware/mbedtls/include/psa; ../../../../../../../middleware/mbedtls/library; ../../../../../../../middleware/mcuboot/boot/bootutil/include; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto; ../../../../../../../middleware/mcuboot/boot/bootutil/src; ../../../../../../../middleware/mcuboot/platform_common; ../../../../../../../middleware/stcryptolib/include; ../../../../../../../middleware/stcryptolib/include/cipher; ../../../../../../../middleware/stcryptolib/include/drbg; ../../../../../../../middleware/stcryptolib/include/ecc; ../../../../../../../middleware/stcryptolib/include/hash; ../../../../../../../middleware/stcryptolib/include/hbs; ../../../../../../../middleware/stcryptolib/include/kdf; ../../../../../../../middleware/stcryptolib/include/mac; ../../../../../../../middleware/stcryptolib/include/pqc; ../../../../../../../middleware/stcryptolib/include/rsa; ../../../../../../../middleware/stcryptolib/include/utils; ../../../../../../../middleware/stfcf/mbedtls_alt/include/common; ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal; ../../../../../../../middleware/stfcf/mbedtls_alt/include/stcryptolib; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../oemirot; ../../oemirot/generated/hal; ../../oemirot/generated/middleware/stcryptolib; ../../oemirot/generated/middleware/stfcf; ../../oemirot/generated/utilities/basic_stdio; ../../oemirot/user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ..\..\bin\oemirot.hex
  prebuild: python "../../oemirot/project_oemirot.py" prebuild --compiler IAR
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../oemirot/user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group middleware/mbedtls/include/mbedtls
    ../../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cmac.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h gcm.h mbedtls_config.h memory_buffer_alloc.h rsa.h sha256.h version.h
  group middleware/mbedtls/include/psa
    ../../../../../../../middleware/mbedtls/include/psa/: crypto_adjust_config_dependencies.h crypto_platform.h crypto_types.h crypto_values.h crypto.h
  group middleware/mbedtls/library
    ../../../../../../../middleware/mbedtls/library/: aes.c aria.c asn1parse.c asn1write.c base64.c bignum_core.c bignum_core.h bignum_internal.h bignum.c bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c cipher_wrap.c cipher.c cmac.c constant_time_internal.h constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp_curves.c ecp.c entropy_poll.c entropy.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c nist_kw.c oid.c pem.c pk_ecc.c pk_wrap.c pk.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform_util.c platform.c poly1305.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_random.c psa_crypto_random.h psa_crypto_rsa.c psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto.c psa_its_file.c psa_util_internal.h psa_util.c ripemd160.c rsa_alt_helpers.c rsa_alt_helpers.h rsa.c sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version_features.c version.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509.c x509write_crt.c x509write_csr.c x509write.c
  group middleware/mcuboot
    ../../../../../../../middleware/mcuboot/: LICENSE.md README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/mcuboot/boot/bootutil/include/bootutil
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/: boot_hooks.h boot_public_hooks.h boot_record.h boot_status.h bootutil_log.h bootutil_public.h bootutil.h caps.h enc_key_public.h enc_key.h fault_injection_hardening_delay_rng.h fault_injection_hardening.h ignore.h image.h mcuboot_status.h ramload.h security_cnt.h sign_key.h
  group middleware/mcuboot/boot/bootutil/include/bootutil/crypto
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto/: aes_ctr.h common.h ecdh_p256.h ecdsa.h hmac_sha256.h sha.h
  group middleware/mcuboot/boot/bootutil/src
    ../../../../../../../middleware/mcuboot/boot/bootutil/src/: bootutil_misc.c bootutil_misc.h bootutil_priv.h bootutil_public.c caps.c encrypted.c fault_injection_hardening_delay_rng_mbedtls.c fault_injection_hardening.c image_ecdsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_priv.h swap_scratch.c tlv.c
  group middleware/mcuboot/docs
    ../../../../../../../middleware/mcuboot/docs/: design.md ecdsa.md encrypted_images.md index.md release-notes.md
  group middleware/mcuboot/platform_common
    ../../../../../../../middleware/mcuboot/platform_common/: boot_hal.h cryptoboot_hal.h Driver_Common.h Driver_Flash.h fih.h flash_map_backend.h flash_map_extended.c flash_map_legacy.c flash_map.c flash_map.h main.c mcuboot_logging.h plat_defs.h plat_nv_counters.h security_cnt.c sysflash.h
  group middleware/stcryptolib
    ../../../../../../../middleware/stcryptolib/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stcryptolib/include
    ../../../../../../../middleware/stcryptolib/include/: cmox_common.h cmox_crypto.h cmox_cta.h cmox_default_config.h cmox_default_defs.h cmox_info.h cmox_init.h cmox_low_level.h
  group middleware/stcryptolib/include/cipher
    ../../../../../../../middleware/stcryptolib/include/cipher/: cmox_blockcipher.h cmox_cbc.h cmox_ccm.h cmox_cfb.h cmox_chacha20.h cmox_chachapoly.h cmox_check_default_aes.h cmox_check_default_gcm.h cmox_cipher_retvals.h cmox_cipher.h cmox_ctr.h cmox_ecb.h cmox_gcm.h cmox_keywrap.h cmox_ofb.h cmox_xts.h
  group middleware/stcryptolib/include/drbg
    ../../../../../../../middleware/stcryptolib/include/drbg/: cmox_ctr_drbg.h cmox_drbg_retvals.h cmox_drbg.h
  group middleware/stcryptolib/include/ecc
    ../../../../../../../middleware/stcryptolib/include/ecc/: cmox_ecc_custom_curves.h cmox_ecc_retvals.h cmox_ecc_types.h cmox_ecc.h cmox_ecdh.h cmox_ecdsa.h cmox_eddsa.h cmox_sm2.h
  group middleware/stcryptolib/include/hash
    ../../../../../../../middleware/stcryptolib/include/hash/: cmox_hash_retvals.h cmox_hash.h cmox_md.h cmox_sha1.h cmox_sha224.h cmox_sha256.h cmox_sha3.h cmox_sha384.h cmox_sha512.h cmox_sm3.h cmox_sponge.h
  group middleware/stcryptolib/include/hbs
    ../../../../../../../middleware/stcryptolib/include/hbs/: cmox_hbs_retvals.h cmox_hbs.h
  group middleware/stcryptolib/include/kdf
    ../../../../../../../middleware/stcryptolib/include/kdf/: cmox_hkdf.h cmox_kdf_retvals.h cmox_kdf.h cmox_x963_kdf.h
  group middleware/stcryptolib/include/mac
    ../../../../../../../middleware/stcryptolib/include/mac/: cmox_cmac.h cmox_hmac.h cmox_kmac.h cmox_mac_retvals.h cmox_mac.h
  group middleware/stcryptolib/include/pqc
    ../../../../../../../middleware/stcryptolib/include/pqc/: cmox_pqc_config.h cmox_pqc_dsa.h cmox_pqc_kem.h cmox_pqc_retvals.h cmox_pqc_types.h
  group middleware/stcryptolib/include/rsa
    ../../../../../../../middleware/stcryptolib/include/rsa/: cmox_rsa_pkcs1v15.h cmox_rsa_pkcs1v22.h cmox_rsa_retvals.h cmox_rsa_types.h cmox_rsa.h
  group middleware/stcryptolib/include/utils
    ../../../../../../../middleware/stcryptolib/include/utils/: cmox_utils_compare.h cmox_utils_membuf.h cmox_utils_retvals.h
  group middleware/stcryptolib/lib
    ../../../../../../../middleware/stcryptolib/lib/: libSTM32Cryptographic_CM33.a
  group middleware/stfcf
    ../../../../../../../middleware/stfcf/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stfcf/mbedtls_alt/include/common
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/common/: aes_alt.h entropy_hardware_alt.h sha256_alt.h sha512_alt.h
  group middleware/stfcf/mbedtls_alt/include/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal/: hal_sha256_alt.h hal_sha512_alt.h
  group middleware/stfcf/mbedtls_alt/include/stcryptolib
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/stcryptolib/: stcryptolib_aes_alt.h
  group middleware/stfcf/mbedtls_alt/source/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/source/hal/: entropy_hardware_alt.c sha256_alt.c sha512_alt.c
  group middleware/stfcf/mbedtls_alt/source/stcryptolib
    ../../../../../../../middleware/stfcf/mbedtls_alt/source/stcryptolib/: aes_alt.c ecdh_alt.c ecdsa_alt.c
  group oemirot
    ../../oemirot/: boot_hal_cfg.h boot_hal_flowcontrol.h boot_hal_hash_ref.c boot_hal_hash_ref.h boot_hal_imagevalid.h boot_hal_legacy.h boot_hal_utils.h boot_hal.c boot_nv_counters.c cmsis.h flash_layout.h keys_map.c low_level_device.c low_level_flash.c low_level_flash.h low_level_obkeys_device.c low_level_obkeys.c low_level_obkeys.h low_level_rng.c low_level_rng.h low_level_security_config.h low_level_security.c low_level_security.h mcuboot_config.h region_defs.h tick.c
  group oemirot/generated/hal
    ../../oemirot/generated/hal/: mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_flash.c mx_flash.h mx_hal_def.h mx_hash.c mx_hash.h mx_icache.c mx_icache.h mx_ramcfg.c mx_ramcfg.h mx_rcc.c mx_rcc.h mx_rng.c mx_rng.h mx_sbs.c mx_sbs.h mx_system.c mx_system.h mx_tamp.c mx_tamp.h mx_usart2.c mx_usart2.h stm32g5xx_hal_conf.h
  group oemirot/generated/middleware/stcryptolib
    ../../oemirot/generated/middleware/stcryptolib/: mx_cmox_config.h
  group oemirot/generated/middleware/stfcf
    ../../oemirot/generated/middleware/stfcf/: mx_mbedtls_alt_config.h mx_mbedtls_config.h mx_stfcf_config.h
  group oemirot/generated/utilities/basic_stdio
    ../../oemirot/generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group oemirot/user_modifiable/Device/STM32G564RET3
    ../../oemirot/user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_flash.c stm32g5xx_hal_flash.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_hash.c stm32g5xx_hal_hash.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_ramcfg.c stm32g5xx_hal_ramcfg.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_rng.c stm32g5xx_hal_rng.h stm32g5xx_hal_sbs.c stm32g5xx_hal_sbs.h stm32g5xx_hal_tamp.c stm32g5xx_hal_tamp.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_ramcfg.h stm32g5xx_ll_rcc.h stm32g5xx_ll_rng.h stm32g5xx_ll_sbs.h stm32g5xx_ll_tamp.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
  group utilities/rot_provisioning
    ../../../../../../../utilities/rot_provisioning/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
