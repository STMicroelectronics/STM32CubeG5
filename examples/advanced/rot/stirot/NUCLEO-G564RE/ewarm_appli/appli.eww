<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\appli.ewp</path>
    </project>
</workspace>