# IAR project sequencer_gpio_toggle.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../stm32g5xx_drivers/timebases; ../../../../../../../utilities/sequencer; ../../../../../../../utilities/sequencer/templates; ../../../application; ../../generated/hal; ../../generated/utilities/sequencer; ../../user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h stm32g5xx_hal_conf.h
  group generated/utilities/sequencer
    ../../generated/utilities/sequencer/: mx_seq.c mx_seq.h seq_user_conf.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_utils.h
  group user_modifiable/Device/STM32G564RET3
    ../../user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/sequencer
    ../../../../../../../utilities/sequencer/: README.md sequencer.c sequencer.h SW_Security_Level.md
  group utilities/sequencer/templates
    ../../../../../../../utilities/sequencer/templates/: seq_user_conf_template.h
