<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_play_gate_xor.ewp</path>
    </project>
</workspace>