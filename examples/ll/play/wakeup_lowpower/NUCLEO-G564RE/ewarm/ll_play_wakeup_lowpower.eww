<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_play_wakeup_lowpower.ewp</path>
    </project>
</workspace>
