<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_spi_half_duplex_one_board_com_it.ewp</path>
    </project>
</workspace>