<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_hrtim_basic_arbitrary_waveform.ewp</path>
    </project>
</workspace>