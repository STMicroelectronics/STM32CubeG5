<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_hrtim_basic_single_pwm.ewp</path>
    </project>
</workspace>