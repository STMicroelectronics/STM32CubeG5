# IAR project ll_cordic_sincos_it.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../arch/cmsis_dsp/Include; ../../../../../../../arch/cmsis_dsp/PrivateInclude; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/ll; ../../../application; ../../generated/hal; ../../user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group arch/cmsis_dsp/Include
    ../../../../../../../arch/cmsis_dsp/Include/: arm_common_tables_f16.h arm_common_tables.h arm_const_structs_f16.h arm_const_structs.h arm_math_f16.h arm_math.h
  group arch/cmsis_dsp/Source/BasicMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group arch/cmsis_dsp/Source/BayesFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group arch/cmsis_dsp/Source/CommonTables
    ../../../../../../../arch/cmsis_dsp/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group arch/cmsis_dsp/Source/ComplexMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group arch/cmsis_dsp/Source/ControllerFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ControllerFunctions/: ControllerFunctions.c
  group arch/cmsis_dsp/Source/DistanceFunctions
    ../../../../../../../arch/cmsis_dsp/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group arch/cmsis_dsp/Source/FastMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group arch/cmsis_dsp/Source/FilteringFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group arch/cmsis_dsp/Source/InterpolationFunctions
    ../../../../../../../arch/cmsis_dsp/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group arch/cmsis_dsp/Source/MatrixFunctions
    ../../../../../../../arch/cmsis_dsp/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group arch/cmsis_dsp/Source/QuaternionMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group arch/cmsis_dsp/Source/StatisticsFunctions
    ../../../../../../../arch/cmsis_dsp/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group arch/cmsis_dsp/Source/SupportFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group arch/cmsis_dsp/Source/SVMFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group arch/cmsis_dsp/Source/TransformFunctions
    ../../../../../../../arch/cmsis_dsp/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group arch/cmsis_dsp/Source/WindowFunctions
    ../../../../../../../arch/cmsis_dsp/Source/WindowFunctions/: WindowFunctions.c
  group generated/hal
    ../../generated/hal/: mx_cordic1.c mx_cordic1.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h stm32_ll.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_cordic.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_utils.h
  group user_modifiable/Device/STM32G564RET3
    ../../user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h ll_example.h main.c main.h stm32g5xx_ll_example.c
    ../../../: README.md
