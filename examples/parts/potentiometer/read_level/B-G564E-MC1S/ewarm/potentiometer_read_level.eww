<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\potentiometer_read_level.ewp</path>
    </project>
</workspace>