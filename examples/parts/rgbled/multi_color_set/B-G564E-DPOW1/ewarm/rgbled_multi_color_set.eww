<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\rgbled_multi_color_set.ewp</path>
    </project>
</workspace>