<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_fmac_iir_it_to_dac_dma.ewp</path>
    </project>
</workspace>