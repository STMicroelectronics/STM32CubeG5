<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_ns\hal_gtzc_uart_dma_secure_nonsecure_ns.ewp</path>
    </project>
</workspace>
