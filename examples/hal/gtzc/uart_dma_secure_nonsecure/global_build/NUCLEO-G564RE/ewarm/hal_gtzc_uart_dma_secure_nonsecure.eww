<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\secure\NUCLEO-G564RE\ewarm\project_s\hal_gtzc_uart_dma_secure_nonsecure_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\non_secure\NUCLEO-G564RE\ewarm\project_ns\hal_gtzc_uart_dma_secure_nonsecure_ns.ewp</path>
    </project>
</workspace>
