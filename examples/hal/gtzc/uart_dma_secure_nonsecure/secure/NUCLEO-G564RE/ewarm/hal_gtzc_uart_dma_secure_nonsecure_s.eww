<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_s\hal_gtzc_uart_dma_secure_nonsecure_s.ewp</path>
    </project>
</workspace>
