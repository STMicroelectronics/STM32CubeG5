# IAR project hal_gtzc_uart_dma_secure_nonsecure_s.ewp, settings and files
configuration release (ARM, debug)
  General.CoreVariant: 61
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --diag_suppress=Pe1757 --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../../stm32g5xx_drivers/ll; ../../../application/secure; ../../../../secure_nsclib; ../../generated; ../../generated/hal
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G573xx; _RTE_
  AARM.AUserIncludes: ../../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../../stm32g5xx_drivers/ll; ../../../application/secure; ../../../application/secure_nsclib; ../../generated; ../../generated/hal; ../../_release_IAR_NUCLEO-G56R4E
  OBJCOPY.OOCOutputFile: hal_gtzc_uart_dma_secure_nonsecure_s.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET6/stm32g564xe_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_def.h mx_dma_tee.c mx_dma_tee.h mx_gpio_tee.c mx_gpio_tee.h mx_gtzc_tee.c mx_gtzc_tee.h mx_hal_def.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tee.c mx_tee.h stm32_external_env.h stm32g5xx_hal_conf.h
  group stm32g5xx_dfp/Include
    ../../generated/hal/: partition_stm32g564xx.h
    ../../../../../../../../stm32g5xx_dfp/Include/: stm32g564xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md
  group stm32g5xx_drivers/doc
    ../../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal.c stm32g5xx_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_flash.c stm32g5xx_hal_flash.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gtzc.c stm32g5xx_hal_gtzc.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h
  group stm32g5xx_drivers/ll
    ../../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_gtzc.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h
  group user_modifiable/Device/STM32G564RET6
    ../../user_modifiable/Device/STM32G564RET6/: startup_stm32g564xx.c system_stm32g5xx_s.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h secure_nsclib.c
    ../../../../: README.md
    ../../../../secure_nsclib/: secure_nsclib.h
