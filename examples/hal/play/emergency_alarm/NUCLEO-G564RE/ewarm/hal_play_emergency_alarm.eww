<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_play_emergency_alarm.ewp</path>
    </project>
</workspace>