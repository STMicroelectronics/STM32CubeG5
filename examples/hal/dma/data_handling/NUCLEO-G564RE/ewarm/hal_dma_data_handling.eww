<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_dma_data_handling.ewp</path>
    </project>
</workspace>