<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_dts_get_temperature_trigger_hw_it.ewp</path>
    </project>
</workspace>