<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_rcc_lse_config.ewp</path>
    </project>
</workspace>