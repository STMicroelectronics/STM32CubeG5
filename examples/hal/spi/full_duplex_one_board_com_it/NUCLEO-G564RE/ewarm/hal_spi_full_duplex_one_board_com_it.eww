<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_spi_full_duplex_one_board_com_it.ewp</path>
    </project>
</workspace>