# Keil uVision project template_no_os.uvprojx, settings and files
target template_no_os_AC6 (6230000::V6.23::ARMCLANG)
  device: STM32G564QET3Q STMicroelectronics
  pack: STMicroelectronics.stm32g5xx_dfp.2.0.0-beta.4
  cpu: IRAM(0x20000000,0x1C000) IRAM2(0x30000000,0x1C000) IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template_no_os
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: STM32G564xx
  c include: ..\..\..\..\..\stm32g5xx_drivers\hal;..\..\..\..\..\stm32g5xx_drivers\ll;..\..\..\..\..\arch\cmsis\CMSIS\Core\Include;..\..\..\..\..\stm32g5xx_dfp\Include;..\generated\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x30000000 size 0x1c000
  scatter file: ..\user_modifiable\Device\STM32G564QET3Q\stm32g564xe_flash.sct
  group application
    ../../application/: main.c
    ../user_modifiable/Device/STM32G564QET3Q/: startup_stm32g564xx.c system_stm32g5xx.c
  group stm32g5xx_hal_drivers
    ../../../../../stm32g5xx_drivers/hal/: stm32g5xx_hal.c stm32g5xx_hal_cortex.c stm32g5xx_hal_exti.c stm32g5xx_hal_flash.c stm32g5xx_hal_flash_itf.c stm32g5xx_hal_gpio.c stm32g5xx_hal_icache.c stm32g5xx_hal_pwr.c stm32g5xx_hal_rcc.c stm32g5xx_hal_sbs.c
  group System
    ../generated/hal/: mx_cortex_nvic.c mx_icache.c mx_rcc.c mx_system.c mx_cortex_mpu.c
