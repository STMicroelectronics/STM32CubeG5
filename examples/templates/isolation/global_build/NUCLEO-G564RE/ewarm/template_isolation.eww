<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\secure\NUCLEO-G564RE\ewarm\project_s\template_isolation_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\non_secure\NUCLEO-G564RE\ewarm\project_ns\template_isolation_ns.ewp</path>
    </project>
</workspace>
