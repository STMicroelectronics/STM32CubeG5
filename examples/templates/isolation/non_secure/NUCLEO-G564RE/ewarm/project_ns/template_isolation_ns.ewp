# IAR project template_isolation_ns.ewp, settings and files
configuration release (ARM, debug)
  General.CoreVariant: 61
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --diag_suppress=Pe1757 --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../application/secure; ../../../../secure_nsclib; ../../generated/hal; ../../_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G573xx; _RTE_
  AARM.AUserIncludes: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../application; ../../../../secure_nsclib; ../../generated; ../../generated/hal; ../../_release_IAR_NUCLEO-G56R4E
  OBJCOPY.OOCOutputFile: template_isolation_ns.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET6\stm32g564xe_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../../../secure_nsclib/NUCLEO-G564RE/release_IAR/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_hal_def.h mx_icache.c mx_icache.h mx_system.c mx_system.h stm32_external_env.h stm32g5xx_hal_conf.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal.c stm32g5xx_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h
  group user_modifiable/Device/STM32G564RET6
    ../../user_modifiable/Device/STM32G564RET6/: startup_stm32g564xx.c system_stm32g5xx_ns.c
  group UserCode
    ../../../application/: main.c main.h
    ../../../../: README.md
    ../../../../secure_nsclib/: secure_nsclib.h
