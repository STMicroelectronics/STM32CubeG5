<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_s\template_isolation_s.ewp</path>
    </project>
</workspace>
