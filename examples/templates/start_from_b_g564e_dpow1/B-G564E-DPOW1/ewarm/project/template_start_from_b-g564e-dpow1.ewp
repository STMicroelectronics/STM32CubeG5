# IAR project template_start_from_b-g564e-dpow1.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_B-G564E-DPOW1/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../part_drivers/joystick/adc; ../../../../../../part_drivers/led/gpio; ../../../../../../part_drivers/rgbled/pwm_no_control; ../../../../../../part_drivers/tcpp0203; ../../../../../../part_drivers/tcpp0203/interfaces/adc_i2c_exti; ../../../../../../stm32g5xx_dfp/Include; ../../../../../../stm32g5xx_drivers/hal; ../../../../../../stm32g5xx_drivers/ll; ../../../../../../stm32g5xx_drivers/timebases; ../../../../../../utilities/basic_stdio; ../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/parts/joystick; ../../generated/parts/led; ../../generated/parts/rgbled; ../../generated/parts/tcpp0203; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_B-G564E-DPOW1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564REZ3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_adc1.c mx_adc1.h mx_adc3.c mx_adc3.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_i2c4.c mx_i2c4.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim2.c mx_tim2.h mx_tim3.c mx_tim3.h mx_tim4.c mx_tim4.h mx_uart5.c mx_uart5.h stm32_external_env.h stm32g5xx_hal_conf.h
  group generated/parts/joystick
    ../../generated/parts/joystick/: mx_joystick.c mx_joystick.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/parts/rgbled
    ../../generated/parts/rgbled/: mx_rgbled_no_control.c mx_rgbled_no_control.h
  group generated/parts/tcpp0203
    ../../generated/parts/tcpp0203/: mx_tcpp0203.c mx_tcpp0203.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group part_drivers/joystick
    ../../../../../../part_drivers/joystick/: README.md SW_Security_Level.md
  group part_drivers/joystick/adc
    ../../../../../../part_drivers/joystick/adc/: joystick_adc.c joystick_adc.h
  group part_drivers/led
    ../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../part_drivers/led/gpio/: led.h
  group part_drivers/rgbled
    ../../../../../../part_drivers/rgbled/: README.md SW_Security_Level.md
  group part_drivers/rgbled/pwm_no_control
    ../../../../../../part_drivers/rgbled/pwm_no_control/: rgbled.c rgbled.h
  group part_drivers/tcpp0203
    ../../../../../../part_drivers/tcpp0203/: README.md SW_Security_Level.md tcpp0203.c tcpp0203.h
  group part_drivers/tcpp0203/interfaces/adc_i2c_exti
    ../../../../../../part_drivers/tcpp0203/interfaces/adc_i2c_exti/: tcpp0203_io.c tcpp0203_io.h
  group stm32g5xx_dfp
    ../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_adc.c stm32g5xx_hal_adc.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_exti.c stm32g5xx_hal_exti.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_i2c.c stm32g5xx_hal_i2c.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_adc.h stm32g5xx_ll_bus.h stm32g5xx_ll_dbgmcu.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_i2c.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_tim.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group user_modifiable/Device/STM32G564REZ3
    ../../user_modifiable/Device/STM32G564REZ3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
