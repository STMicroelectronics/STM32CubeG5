# IAR project filex_nor_multi_access_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/filex/common/inc; ../../../../../../../middleware/filex/interfaces/nor; ../../../../../../../middleware/filex/ports/freertos/inc; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/levelx/common/inc; ../../../../../../../middleware/levelx/interfaces/nor; ../../../../../../../middleware/levelx/interfaces/nor/w25q128j; ../../../../../../../middleware/levelx/ports/freertos/inc; ../../../../../../../part_drivers/w25q128j; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware/filex; ../../generated/middleware/freertos; ../../generated/middleware/levelx; ../../generated/parts/w25q128j; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_spi1.c mx_spi1.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_usart2.c mx_usart2.h stm32_hal_timebase.h stm32g5xx_hal_conf.h
  group generated/middleware/filex
    ../../generated/middleware/filex/: fx_user.h mx_filex_app.c mx_filex_app.h mx_filex_interfaces.c mx_filex_interfaces.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/levelx
    ../../generated/middleware/levelx/: lx_user.h mx_levelx_app.c mx_levelx_app.h mx_levelx_interfaces.c mx_levelx_interfaces.h
  group generated/parts/w25q128j
    ../../generated/parts/w25q128j/: mx_w25q128j.c mx_w25q128j.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/filex
    ../../../../../../../middleware/filex/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/filex/common/inc
    ../../../../../../../middleware/filex/common/inc/: fx_api.h
  group middleware/filex/common/src
    ../../../../../../../middleware/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get_copy.c fx_directory_default_get.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get_copy.c fx_directory_local_path_get.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get_extended.c fx_directory_long_name_get.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get_extended.c fx_directory_short_name_get.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate_release.c fx_file_extended_truncate.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate_release.c fx_file_truncate.c fx_file_write_notify_set.c fx_file_write.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_check.c fx_media_close_notify_set.c fx_media_close.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_format.c fx_media_open_notify_set.c fx_media_open.c fx_media_read.c fx_media_space_available.c fx_media_volume_get_extended.c fx_media_volume_get.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_unicode_directory_create.c fx_unicode_directory_entry_change.c fx_unicode_directory_entry_read.c fx_unicode_directory_rename.c fx_unicode_directory_search.c fx_unicode_file_create.c fx_unicode_file_rename.c fx_unicode_length_get_extended.c fx_unicode_length_get.c fx_unicode_name_get_extended.c fx_unicode_name_get.c fx_unicode_short_name_get_extended.c fx_unicode_short_name_get.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get_copy.c fxe_directory_default_get.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_get.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get_extended.c fxe_directory_long_name_get.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get_extended.c fxe_directory_short_name_get.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate_release.c fxe_file_extended_truncate.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate_release.c fxe_file_truncate.c fxe_file_write_notify_set.c fxe_file_write.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close_notify_set.c fxe_media_close.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open_notify_set.c fxe_media_open.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get_extended.c fxe_media_volume_get.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c fxe_unicode_directory_create.c fxe_unicode_directory_rename.c fxe_unicode_file_create.c fxe_unicode_file_rename.c fxe_unicode_name_get_extended.c fxe_unicode_name_get.c fxe_unicode_short_name_get_extended.c fxe_unicode_short_name_get.c
  group middleware/filex/interfaces/nor
    ../../../../../../../middleware/filex/interfaces/nor/: stm32_fx_nor_flash_driver.c stm32_fx_nor_flash_driver.h
  group middleware/filex/ports/freertos/src
    ../../../../../../../middleware/filex/ports/freertos/src/: fx_os_current_thread_tls_get.c fx_os_current_thread_tls_set.c fx_os_mutex_create.c fx_os_mutex_delete.c fx_os_timer_create.c
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/levelx
    ../../../../../../../middleware/levelx/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/levelx/common/inc
    ../../../../../../../middleware/levelx/common/inc/: lx_api.h
  group middleware/levelx/common/src
    ../../../../../../../middleware/levelx/common/src/: lx_nor_flash_block_reclaim.c lx_nor_flash_close.c lx_nor_flash_defragment.c lx_nor_flash_driver_block_erase.c lx_nor_flash_driver_read.c lx_nor_flash_driver_write.c lx_nor_flash_extended_cache_enable.c lx_nor_flash_format.c lx_nor_flash_initialize.c lx_nor_flash_logical_sector_find.c lx_nor_flash_next_block_to_erase_find.c lx_nor_flash_open_extended.c lx_nor_flash_open.c lx_nor_flash_partial_defragment.c lx_nor_flash_physical_sector_allocate.c lx_nor_flash_sector_mapping_cache_invalidate.c lx_nor_flash_sector_read.c lx_nor_flash_sector_release.c lx_nor_flash_sector_write.c lx_nor_flash_system_error.c
  group middleware/levelx/interfaces/nor/w25q128j
    ../../../../../../../middleware/levelx/interfaces/nor/w25q128j/: stm32_lx_w25q128j_nor_flash_dma_os_driver.c stm32_lx_w25q128j_nor_flash_dma_os_driver.h
  group part_drivers/w25q128j
    ../../../../../../../part_drivers/w25q128j/: README.md SW_Security_Level.md w25q128j.c w25q128j.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_exti.c stm32g5xx_hal_exti.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_spi.c stm32g5xx_hal_spi.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_spi.h stm32g5xx_ll_tim.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group stm32g5xx_drivers/timebases
    ../../../../../../../stm32g5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32G564RET3
    ../../user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
