# IAR project usbpd_drp_pd_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_B-G564E-DPOW1/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/usbpd/common/core; ../../../../../../../middleware/usbpd/common/utils/tracer; ../../../../../../../middleware/usbpd/interfaces/phy; ../../../../../../../middleware/usbpd/interfaces/timerserver; ../../../../../../../middleware/usbpd/interfaces/trace; ../../../../../../../part_drivers/led/gpio; ../../../../../../../part_drivers/tcpp0203; ../../../../../../../part_drivers/tcpp0203/interfaces/adc_i2c_exti; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../application; ../../generated/hal; ../../generated/middleware/freertos; ../../generated/middleware/usbpd; ../../generated/parts/led; ../../generated/parts/tcpp0203; ../../user_modifiable/_release_IAR_B-G564E-DPOW1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564REZ3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_adc3.c mx_adc3.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_i2c4.c mx_i2c4.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim1.c mx_tim1.h mx_tim6.c mx_tim6.h mx_uart5.c mx_uart5.h mx_ucpd1.c mx_ucpd1.h stm32_external_env.h stm32_hal_timebase.h stm32g5xx_hal_conf.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/usbpd
    ../../generated/middleware/usbpd/: mx_usbpd_app.c mx_usbpd_app.h mx_usbpd_dpm_user_app.c mx_usbpd_dpm_user_app.h mx_usbpd_tcpp0203_pwr_hw_if.c mx_usbpd_tcpp0203_pwr_hw_if.h usbpd_config.h usbpd_pdo_defs.c
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/parts/tcpp0203
    ../../generated/parts/tcpp0203/: mx_tcpp0203.c mx_tcpp0203.h
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/usbpd
    ../../../../../../../middleware/usbpd/: README.md Release_Notes.md SW_Security_Level.md
  group middleware/usbpd/common/core
    ../../../../../../../middleware/usbpd/common/core/: usbpd_phy.c usbpd_pwr.c usbpd_timersserver.c usbpd_trace.c
  group middleware/usbpd/common/lib
    ../../../../../../../middleware/usbpd/common/lib/: USBPD_LIB_FULL_CM33_wc32.a
  group middleware/usbpd/common/utils/tracer
    ../../../../../../../middleware/usbpd/common/utils/tracer/: usbpd_utils_tracer.c
  group middleware/usbpd/interfaces/phy
    ../../../../../../../middleware/usbpd/interfaces/phy/: usbpd_cad_hw_if.c usbpd_phy_hw_if.c
  group middleware/usbpd/interfaces/timerserver
    ../../../../../../../middleware/usbpd/interfaces/timerserver/: usbpd_timerserver_hw_if.c
  group middleware/usbpd/interfaces/trace
    ../../../../../../../middleware/usbpd/interfaces/trace/: usbpd_utils_tracer_hw_if.c
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group part_drivers/tcpp0203
    ../../../../../../../part_drivers/tcpp0203/: README.md SW_Security_Level.md tcpp0203.c tcpp0203.h
  group part_drivers/tcpp0203/interfaces/adc_i2c_exti
    ../../../../../../../part_drivers/tcpp0203/interfaces/adc_i2c_exti/: tcpp0203_io.c tcpp0203_io.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_adc.c stm32g5xx_hal_adc.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_exti.c stm32g5xx_hal_exti.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_i2c.c stm32g5xx_hal_i2c.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal_ucpd.c stm32g5xx_hal_ucpd.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_adc.h stm32g5xx_ll_bus.h stm32g5xx_ll_dbgmcu.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_i2c.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_tim.h stm32g5xx_ll_ucpd.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group stm32g5xx_drivers/timebases
    ../../../../../../../stm32g5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32G564REZ3
    ../../user_modifiable/Device/STM32G564REZ3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
