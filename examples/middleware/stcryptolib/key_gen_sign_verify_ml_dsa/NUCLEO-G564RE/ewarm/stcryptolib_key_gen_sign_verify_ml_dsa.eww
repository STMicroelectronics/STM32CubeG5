<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_key_gen_sign_verify_ml_dsa.ewp</path>
    </project>
</workspace>