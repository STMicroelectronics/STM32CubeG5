<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_key_gen_encap_decap_ml_kem.ewp</path>
    </project>
</workspace>