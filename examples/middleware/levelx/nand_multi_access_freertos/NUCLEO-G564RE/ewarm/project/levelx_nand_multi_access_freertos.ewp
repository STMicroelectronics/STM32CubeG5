# IAR project levelx_nand_multi_access_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/levelx/common/inc; ../../../../../../../middleware/levelx/interfaces/nand; ../../../../../../../middleware/levelx/interfaces/nand/w25n01gvxx; ../../../../../../../middleware/levelx/ports/freertos/inc; ../../../../../../../part_drivers/w25n01gvxx; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware/freertos; ../../generated/middleware/levelx; ../../generated/parts/w25n01gvxx; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_spi1.c mx_spi1.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_usart2.c mx_usart2.h stm32_hal_timebase.h stm32g5xx_hal_conf.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/levelx
    ../../generated/middleware/levelx/: lx_user.h mx_levelx_app.c mx_levelx_app.h mx_levelx_interfaces.c mx_levelx_interfaces.h
  group generated/parts/w25n01gvxx
    ../../generated/parts/w25n01gvxx/: mx_w25n01gvxx.c mx_w25n01gvxx.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/levelx
    ../../../../../../../middleware/levelx/: README.md ST_Release_Notes.md
  group middleware/levelx/common/inc
    ../../../../../../../middleware/levelx/common/inc/: lx_api.h
  group middleware/levelx/common/src
    ../../../../../../../middleware/levelx/common/src/: lx_nand_flash_256byte_ecc_check.c lx_nand_flash_256byte_ecc_compute.c lx_nand_flash_block_allocate.c lx_nand_flash_block_data_move.c lx_nand_flash_block_find.c lx_nand_flash_block_mapping_set.c lx_nand_flash_block_status_set.c lx_nand_flash_close.c lx_nand_flash_data_page_copy.c lx_nand_flash_defragment.c lx_nand_flash_driver_block_erase.c lx_nand_flash_driver_block_erased_verify.c lx_nand_flash_driver_block_status_get.c lx_nand_flash_driver_block_status_set.c lx_nand_flash_driver_page_erased_verify.c lx_nand_flash_erase_count_set.c lx_nand_flash_extended_cache_enable.c lx_nand_flash_format_extended.c lx_nand_flash_format.c lx_nand_flash_free_block_list_add.c lx_nand_flash_initialize.c lx_nand_flash_logical_group_compact.c lx_nand_flash_mapped_block_list_add.c lx_nand_flash_mapped_block_list_get.c lx_nand_flash_mapped_block_list_remove.c lx_nand_flash_memory_initialize.c lx_nand_flash_metadata_allocate.c lx_nand_flash_metadata_build.c lx_nand_flash_metadata_write.c lx_nand_flash_open_extended.c lx_nand_flash_open.c lx_nand_flash_page_ecc_check.c lx_nand_flash_page_ecc_compute.c lx_nand_flash_partial_defragment.c lx_nand_flash_sector_read.c lx_nand_flash_sector_release.c lx_nand_flash_sector_write.c lx_nand_flash_sectors_read.c lx_nand_flash_sectors_release.c lx_nand_flash_sectors_write.c lx_nand_flash_system_error.c
  group middleware/levelx/interfaces/nand/w25n01gvxx
    ../../../../../../../middleware/levelx/interfaces/nand/w25n01gvxx/: stm32_lx_w25n01gvxx_nand_flash_dma_os_driver.c stm32_lx_w25n01gvxx_nand_flash_dma_os_driver.h
  group part_drivers/w25n01gvxx
    ../../../../../../../part_drivers/w25n01gvxx/: README.md SW_Security_Level.md w25n01gvxx.c w25n01gvxx.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_spi.c stm32g5xx_hal_spi.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_spi.h stm32g5xx_ll_tim.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group stm32g5xx_drivers/timebases
    ../../../../../../../stm32g5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32G564RET3
    ../../user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
