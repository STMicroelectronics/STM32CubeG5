# IAR project usbx_host_hid_cdc_acm_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-G564RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/usbx/common/core/inc; ../../../../../../../middleware/usbx/common/usbx_host_classes/inc; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_host_controllers; ../../../../../../../middleware/usbx/ports/freertos/inc; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../utilities/advanced_trace/core; ../../../../../../../utilities/advanced_trace/interface_data; ../../../../../../../utilities/advanced_trace/templates; ../../../application; ../../generated/hal; ../../generated/middleware/freertos; ../../generated/middleware/usbx; ../../generated/parts/led; ../../generated/utilities/advanced_trace; ../../user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_usart2.c mx_usart2.h mx_usb_drd_fs.c mx_usb_drd_fs.h stm32_hal_timebase.h stm32g5xx_hal_conf.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/usbx
    ../../generated/middleware/usbx/: mx_usbx_app.c mx_usbx_app.h mx_usbx_host_cdc_acm.c mx_usbx_host_cdc_acm.h mx_usbx_host_hid_keyboard.c mx_usbx_host_hid_keyboard.h mx_usbx_host_hid_mouse.c mx_usbx_host_hid_mouse.h mx_usbx_host.c mx_usbx_host.h ux_user.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/advanced_trace
    ../../generated/utilities/advanced_trace/: adv_trace_user_conf.h mx_advanced_trace_app.c mx_advanced_trace_app.h
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/usbx
    ../../../../../../../middleware/usbx/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/usbx/common/core/inc
    ../../../../../../../middleware/usbx/common/core/inc/: ux_api.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_utility.h
  group middleware/usbx/common/core/src
    ../../../../../../../middleware/usbx/common/core/src/: ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_request.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get_big_endian.c ux_utility_long_get.c ux_utility_long_put_big_endian.c ux_utility_long_put.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_allocate.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free_block_best_get.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get_big_endian.c ux_utility_short_get.c ux_utility_short_put_big_endian.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group middleware/usbx/common/usbx_host_classes/inc
    ../../../../../../../middleware/usbx/common/usbx_host_classes/inc/: ux_host_class_cdc_acm.h ux_host_class_hid_keyboard.h ux_host_class_hid_mouse.h ux_host_class_hid.h
  group middleware/usbx/common/usbx_host_classes/src
    ../../../../../../../middleware/usbx/common/usbx_host_classes/src/: ux_host_class_cdc_acm_activate.c ux_host_class_cdc_acm_capabilities_get.c ux_host_class_cdc_acm_command.c ux_host_class_cdc_acm_configure.c ux_host_class_cdc_acm_deactivate.c ux_host_class_cdc_acm_endpoints_get.c ux_host_class_cdc_acm_entry.c ux_host_class_cdc_acm_ioctl.c ux_host_class_cdc_acm_read.c ux_host_class_cdc_acm_reception_callback.c ux_host_class_cdc_acm_reception_start.c ux_host_class_cdc_acm_reception_stop.c ux_host_class_cdc_acm_transfer_request_completed.c ux_host_class_cdc_acm_write.c ux_host_class_hid_activate.c ux_host_class_hid_client_register.c ux_host_class_hid_client_search.c ux_host_class_hid_configure.c ux_host_class_hid_deactivate.c ux_host_class_hid_descriptor_parse.c ux_host_class_hid_entry.c ux_host_class_hid_field_decompress.c ux_host_class_hid_global_item_parse.c ux_host_class_hid_idle_get.c ux_host_class_hid_idle_set.c ux_host_class_hid_instance_clean.c ux_host_class_hid_interrupt_endpoint_search.c ux_host_class_hid_item_data_get.c ux_host_class_hid_keyboard_activate.c ux_host_class_hid_keyboard_callback.c ux_host_class_hid_keyboard_deactivate.c ux_host_class_hid_keyboard_entry.c ux_host_class_hid_keyboard_ioctl.c ux_host_class_hid_keyboard_key_get.c ux_host_class_hid_keyboard_thread.c ux_host_class_hid_local_item_parse.c ux_host_class_hid_main_item_parse.c ux_host_class_hid_mouse_activate.c ux_host_class_hid_mouse_buttons_get.c ux_host_class_hid_mouse_callback.c ux_host_class_hid_mouse_deactivate.c ux_host_class_hid_mouse_entry.c ux_host_class_hid_mouse_position_get.c ux_host_class_hid_mouse_wheel_get.c ux_host_class_hid_periodic_report_start.c ux_host_class_hid_periodic_report_stop.c ux_host_class_hid_protocol_get.c ux_host_class_hid_protocol_set.c ux_host_class_hid_report_add.c ux_host_class_hid_report_callback_register.c ux_host_class_hid_report_compress.c ux_host_class_hid_report_decompress.c ux_host_class_hid_report_descriptor_get.c ux_host_class_hid_report_get.c ux_host_class_hid_report_id_get.c ux_host_class_hid_report_item_analyse.c ux_host_class_hid_report_set.c ux_host_class_hid_resources_free.c ux_host_class_hid_transfer_request_completed.c
  group middleware/usbx/interfaces/usbx_stm32_host_controllers
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_host_controllers/: ux_hcd_stm32_callback.c ux_hcd_stm32_controller_disable.c ux_hcd_stm32_ed_obtain.c ux_hcd_stm32_endpoint_create.c ux_hcd_stm32_endpoint_destroy.c ux_hcd_stm32_endpoint_reset.c ux_hcd_stm32_entry.c ux_hcd_stm32_frame_number_get.c ux_hcd_stm32_initialize.c ux_hcd_stm32_least_traffic_list_get.c ux_hcd_stm32_periodic_schedule.c ux_hcd_stm32_port_disable.c ux_hcd_stm32_port_enable.c ux_hcd_stm32_port_reset.c ux_hcd_stm32_port_resume.c ux_hcd_stm32_port_status_get.c ux_hcd_stm32_port_suspend.c ux_hcd_stm32_power_down_port.c ux_hcd_stm32_power_on_port.c ux_hcd_stm32_register_callback.c ux_hcd_stm32_request_bulk_transfer.c ux_hcd_stm32_request_control_transfer.c ux_hcd_stm32_request_periodic_transfer.c ux_hcd_stm32_request_trans_finish.c ux_hcd_stm32_request_trans_prepare.c ux_hcd_stm32_request_transfer.c ux_hcd_stm32_transfer_abort.c ux_hcd_stm32.h
  group middleware/usbx/ports/freertos/src
    ../../../../../../../middleware/usbx/ports/freertos/src/: ux_os_utility_event_flags_create.c ux_os_utility_event_flags_delete.c ux_os_utility_event_flags_get.c ux_os_utility_event_flags_set.c ux_os_utility_mutex_create.c ux_os_utility_mutex_delete.c ux_os_utility_mutex_off.c ux_os_utility_mutex_on.c ux_os_utility_semaphore_create.c ux_os_utility_semaphore_delete.c ux_os_utility_semaphore_get.c ux_os_utility_semaphore_put.c ux_os_utility_sleep_ms.c ux_os_utility_thread_create.c ux_os_utility_thread_delete.c ux_os_utility_thread_identify.c ux_os_utility_thread_relinquish.c ux_os_utility_thread_resume.c ux_os_utility_thread_schedule_other.c ux_os_utility_thread_sleep.c ux_os_utility_thread_suspend.c ux_os_utility_timer_create.c ux_os_utility_timer_delete.c ux_os_utility_timer_start.c
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_exti.c stm32g5xx_hal_exti.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_hcd.c stm32g5xx_hal_hcd.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h stm32g5xx_usb_core_def.h stm32g5xx_usb_drd_core.c stm32g5xx_usb_drd_core.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_tim.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group stm32g5xx_drivers/timebases
    ../../../../../../../stm32g5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32G564RET3
    ../../user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/advanced_trace
    ../../../../../../../utilities/advanced_trace/: README.md SW_Security_Level.md
  group utilities/advanced_trace/core
    ../../../../../../../utilities/advanced_trace/core/: adv_trace_core.c adv_trace_core.h
  group utilities/advanced_trace/interface_data
    ../../../../../../../utilities/advanced_trace/interface_data/: adv_trace_itf_data.h adv_trace_itfdata_uart.c
  group utilities/advanced_trace/templates
    ../../../../../../../utilities/advanced_trace/templates/: adv_trace_user_conf_template.h
