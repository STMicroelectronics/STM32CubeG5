# IAR project usbx_device_printer_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_B-G564E-DPOW1/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/usbx/common/core/inc; ../../../../../../../middleware/usbx/common/usbx_device_classes/inc; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors; ../../../../../../../middleware/usbx/ports/freertos/inc; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../utilities/advanced_trace/core; ../../../../../../../utilities/advanced_trace/interface_data; ../../../../../../../utilities/advanced_trace/templates; ../../../application; ../../generated/hal; ../../generated/middleware/freertos; ../../generated/middleware/usbx; ../../generated/parts/led; ../../generated/utilities/advanced_trace; ../../user_modifiable/_release_IAR_B-G564E-DPOW1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32G564REZ3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_uart5.c mx_uart5.h mx_usb_drd_fs.c mx_usb_drd_fs.h stm32_hal_timebase.h stm32g5xx_hal_conf.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/usbx
    ../../generated/middleware/usbx/: mx_usbx_app.c mx_usbx_app.h mx_usbx_device_printer.c mx_usbx_device_printer.h mx_usbx_device.c mx_usbx_device.h ux_stm32_device_descriptors_config.h ux_user.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/advanced_trace
    ../../generated/utilities/advanced_trace/: adv_trace_user_conf.h mx_advanced_trace_app.c mx_advanced_trace_app.h
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/usbx
    ../../../../../../../middleware/usbx/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/usbx/common/core/inc
    ../../../../../../../middleware/usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_system.h ux_utility.h
  group middleware/usbx/common/core/src
    ../../../../../../../middleware/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get_big_endian.c ux_utility_long_get.c ux_utility_long_put_big_endian.c ux_utility_long_put.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_allocate.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free_block_best_get.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get_big_endian.c ux_utility_short_get.c ux_utility_short_put_big_endian.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group middleware/usbx/common/usbx_device_classes/inc
    ../../../../../../../middleware/usbx/common/usbx_device_classes/inc/: ux_device_class_printer.h
  group middleware/usbx/common/usbx_device_classes/src
    ../../../../../../../middleware/usbx/common/usbx_device_classes/src/: ux_device_class_printer_activate.c ux_device_class_printer_control_request.c ux_device_class_printer_deactivate.c ux_device_class_printer_entry.c ux_device_class_printer_initialize.c ux_device_class_printer_ioctl.c ux_device_class_printer_read.c ux_device_class_printer_soft_reset.c ux_device_class_printer_uninitialize.c ux_device_class_printer_write.c
  group middleware/usbx/interfaces/usbx_stm32_device_controllers
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_initialize.c ux_dcd_stm32_register_callback.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c ux_dcd_stm32.h
  group middleware/usbx/interfaces/usbx_stm32_device_descriptors
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors/: ux_stm32_device_descriptors.c ux_stm32_device_descriptors.h
  group middleware/usbx/ports/freertos/src
    ../../../../../../../middleware/usbx/ports/freertos/src/: ux_os_utility_event_flags_create.c ux_os_utility_event_flags_delete.c ux_os_utility_event_flags_get.c ux_os_utility_event_flags_set.c ux_os_utility_mutex_create.c ux_os_utility_mutex_delete.c ux_os_utility_mutex_off.c ux_os_utility_mutex_on.c ux_os_utility_semaphore_create.c ux_os_utility_semaphore_delete.c ux_os_utility_semaphore_get.c ux_os_utility_semaphore_put.c ux_os_utility_sleep_ms.c ux_os_utility_thread_create.c ux_os_utility_thread_delete.c ux_os_utility_thread_identify.c ux_os_utility_thread_relinquish.c ux_os_utility_thread_resume.c ux_os_utility_thread_schedule_other.c ux_os_utility_thread_sleep.c ux_os_utility_thread_suspend.c ux_os_utility_timer_create.c ux_os_utility_timer_delete.c ux_os_utility_timer_start.c
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pcd.c stm32g5xx_hal_pcd.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_tim.c stm32g5xx_hal_tim.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h stm32g5xx_hal.c stm32g5xx_hal.h stm32g5xx_usb_core_def.h stm32g5xx_usb_drd_core.c stm32g5xx_usb_drd_core.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_sbs.h stm32g5xx_ll_tim.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group stm32g5xx_drivers/timebases
    ../../../../../../../stm32g5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32G564REZ3
    ../../user_modifiable/Device/STM32G564REZ3/: startup_stm32g564xx.c system_stm32g5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/advanced_trace
    ../../../../../../../utilities/advanced_trace/: README.md SW_Security_Level.md
  group utilities/advanced_trace/core
    ../../../../../../../utilities/advanced_trace/core/: adv_trace_core.c adv_trace_core.h
  group utilities/advanced_trace/interface_data
    ../../../../../../../utilities/advanced_trace/interface_data/: adv_trace_itf_data.h adv_trace_itfdata_uart.c
  group utilities/advanced_trace/templates
    ../../../../../../../utilities/advanced_trace/templates/: adv_trace_user_conf_template.h
